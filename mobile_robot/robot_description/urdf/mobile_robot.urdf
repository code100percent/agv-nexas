Commit message: parmas changed

File: mobile_robot/robot_description/urdf/mobile_robot.urdf (robot description, URDF)
Before this commit: robot mobile_robot_rtabmap, 11 links, 10 joints
Joints:
- joint joint_base_to_lidar: origin xyz=0 0 0.45 rpy=0 0 0 -> xyz=0 0 0.45 rpy=0 0 0.15
